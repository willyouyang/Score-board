# Keil uVision project Score_board.uvprojx, settings and files
target Score_board Configuration (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L051K8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Score_board Configuration
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c misc: --C99
  c include: ..\Inc; ..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32L0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32l0xx_it.c main.c stm32l0xx_hal_msp.c main.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l051xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_dma.c stm32l0xx_hal_rcc.c stm32l0xx_hal.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_uart.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_flash.c
